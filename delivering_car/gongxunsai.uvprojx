# Keil uVision project gongxunsai.uvprojx, settings and files
target gongxunsai (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gongxunsai +hex
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\User;.\User\exti;.\User\key;.\User\led;.\User\uart;.\Libraries\FWlib\inc;.\FreeRTOS\include;.\Libraries\CMSIS;.\FreeRTOS\port\RVDS\ARM_CM3;..\9.5 22h;.\User\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ./Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./User/: main.c stm32f10x_conf.h FreeRTOSConfig.h stm32f10x_it.h stm32f10x_it.c buffer.c Delay.c Driver.c encoder.c flash.c JY62.c MPU6050.c PID.c PWM.c Software_iic.c software_usart.c sys.c VL53.c
    ./User/exti/: bsp_exti.c
    ./User/key/: bsp_key.c
    ./User/led/: bsp_led.c
    ./User/uart/: usart.c
    ./User/oled/: OLED.c oled_buffer.c oled_draw.c OLED_Font.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ./Doc/: readme.txt
